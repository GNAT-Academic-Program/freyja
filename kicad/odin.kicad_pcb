# Repository GNAT-Academic-Program/freyja (continued)

## KiCad design kicad/odin.kicad_pcb (continued)

Schematic: slots.kicad_sch

Parts:
C139, C140, C141, C142, C144, C146, C148, C150, C152, C154, C156, C158, C160, C162: 100nF; C_0402_1005Metric; LCSC C1525
C143, C145, C147, C149, C151, C153, C155, C157, C159, C161: 10uF; C_0805_2012Metric; LCSC C15850
C163, C164, C165, C166: 22uF; C_0805_2012Metric; LCSC C86816
F1, F3, F5, F7, F9, F11, F13, F15, F17, F19, F21, F23, F25, F27, F29, F31, F33, F35, F37, F39: 500mA; F1206; LCSC C269115
F2, F6, F10, F14, F18, F22, F26, F30, F34, F38: 1.1A; F1206; LCSC C269119
F4, F8, F12, F16, F20, F24, F28, F32, F36, F40: 1.1A 33V; Fuse_TECHFUSE_SMD2018; LCSC C70150
H1, H2, H3, H4: MountingHole_3.2mm_M3
J3A, J3B, J5A, J5B: HC-PM254-8.5H-2x16PZ; HDR-TH_32P-P2.54-V-F-R2-C16-S2.54; LCSC C22373921
J7, J8: 2.54-2*8P female 8.5mm; HDR-TH_16P-P2.54-V-F-R2-C8-S2.54; LCSC C30734
J19, J20: 2.54-2*3P; HDR-TH_6P-P2.54-V-M-R2-C3-S2.54-1; LCSC C65114
J53, J54, J55, J56, J57, J58, J62, J63, J64, J65: B254N02-0B7P51-H85C32; HDR-TH_7P-P2.54-V-F; LCSC C41426870
MK65, MK66, MK67, MK68, MK69, MK70, MK71, MK72, MK76, MK77: BOOMELE 2.54-1x40P-21mm; cut to 1P; hand/wave sol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; HDR-TH_1P-P2.54-V-M-21MM-C51353; LCSC C51353
R96, R97: 10k; R_0603_1608Metric
U9, U10: SN74LVC8T245PWR; TSSOP-24_L7.8-W4.4-P0.65-LS6.4-BL_1; LCSC C27643

Connections:
+1V8_IO: C139.1, C141.1, J19.5, J20.5, R96.1, R97.1, U9.1 (V_{CCA}), U10.1 (V_{CCA}); also elsewhere on the board
+2V5: J19.3, J20.3; also elsewhere on the board
+3V3: J19.1, J20.1; also elsewhere on the board
+3V3_EXT: F1.1, F3.1, F5.1, F7.1, F11.1, F15.1, F19.1, F23.1, F27.1, F31.1, F35.1, F39.1; also elsewhere on the board
+5V: C140.1, C142.1, U9.23 (V_{CCB}), U9.24 (V_{CCB}), U10.23 (V_{CCB}), U10.24 (V_{CCB}); also elsewhere on the board
+5V_EXT: F2.1, F6.1, F10.1, F14.1, F18.1, F22.1, F26.1, F30.1, F34.1, F38.1; also elsewhere on the board
AUX_RAIL: F4.1, F8.1, F12.1, F16.1, F20.1, F24.1, F28.1, F32.1, F36.1, F40.1; also elsewhere on the board
BUS5V0_DIR: U9.2 (DIR); also elsewhere on the board
BUS5V0_IO0: U9.3 (A1); also elsewhere on the board
BUS5V0_IO1: U9.4 (A2); also elsewhere on the board
BUS5V0_IO2: U9.5 (A3); also elsewhere on the board
BUS5V0_IO3: U9.6 (A4); also elsewhere on the board
BUS5V0_IO4: U9.7 (A5); also elsewhere on the board
BUS5V0_IO5: U9.8 (A6); also elsewhere on the board
BUS5V0_IO6: U9.9 (A7); also elsewhere on the board
BUS5V0_IO7: U9.10 (A8); also elsewhere on the board
BUS5V0_OE_N: R96.2, U9.22 (~OE); also elsewhere on the board
BUS5V0_PIN0: J7.1, U9.21 (B1)
BUS5V0_PIN1: J7.2, U9.20 (B2)
BUS5V0_PIN2: J7.3, U9.19 (B3)
BUS5V0_PIN3: J7.4, U9.18 (B4)
BUS5V0_PIN4: J7.7, U9.17 (B5)
BUS5V0_PIN5: J7.8, U9.16 (B6)
BUS5V0_PIN6: J7.9, U9.15 (B7)
BUS5V0_PIN7: J7.10, U9.14 (B8)
BUS5V1_DIR: U10.2 (DIR); also elsewhere on the board
BUS5V1_IO0: U10.10 (A8); also elsewhere on the board
BUS5V1_IO1: U10.9 (A7); also elsewhere on the board
BUS5V1_IO2: U10.8 (A6); also elsewhere on the board
BUS5V1_IO3: U10.7 (A5); also elsewhere on the board
BUS5V1_IO4: U10.6 (A4); also elsewhere on the board
BUS5V1_IO5: U10.5 (A3); also elsewhere on the board
BUS5V1_IO6: U10.4 (A2); also elsewhere on the board
BUS5V1_IO7: U10.3 (A1); also elsewhere on the board
BUS5V1_OE_N: R97.2, U10.22 (~OE); also elsewhere on the board
BUS5V1_PIN0: J8.1, U10.14 (B8)
BUS5V1_PIN1: J8.2, U10.15 (B7)
BUS5V1_PIN2: J8.3, U10.16 (B6)
BUS5V1_PIN3: J8.4, U10.17 (B5)
BUS5V1_PIN4: J8.7, U10.18 (B4)
BUS5V1_PIN5: J8.8, U10.19 (B3)
BUS5V1_PIN6: J8.9, U10.20 (B2)
BUS5V1_PIN7: J8.10, U10.21 (B1)
GND: C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, J3A.5, J3A.6, J3A.11, J3A.12, J3A.21, J3A.22, J3A.27, J3A.28, J3B.5, J3B.6, J3B.11, J3B.12, J3B.21, J3B.22, J3B.27, J3B.28, J5A.5, J5A.6, J5A.11, J5A.12, J5A.21, J5A.22, J5A.27, J5A.28, J5B.5, J5B.6, J5B.11, J5B.12, J5B.21, J5B.22, J5B.27, J5B.28, J7.5, J7.6, J7.11, J7.12, J8.5, J8.6, J8.11, J8.12, J53.2, J53.4, J53.6, J54.2, J54.4, J54.6, J55.2, J55.4, J55.6, J56.2, J56.4, J56.6, J57.2, J57.4, J57.6, J58.2, J58.4, J58.6, J62.2, J62.4, J62.6, J63.2, J63.4, J63.6, J64.2, J64.4, J64.6, J65.2, J65.4, J65.6, MK65.1, MK66.1, MK67.1, MK68.1, MK69.1, MK70.1, MK71.1, MK72.1, MK76.1, MK77.1, U9.11 (GND), U9.12 (GND), U9.13 (GND), U10.11 (GND), U10.12 (GND), U10.13 (GND); also elsewhere on the board
SLOTA_IO0: J3A.1; also elsewhere on the board
SLOTA_IO1: J3A.2; also elsewhere on the board
SLOTA_IO2: J3A.3; also elsewhere on the board
SLOTA_IO3: J3A.4; also elsewhere on the board
SLOTA_IO4: J3A.7; also elsewhere on the board
SLOTA_IO5: J3A.8; also elsewhere on the board
SLOTA_IO6: J3A.9; also elsewhere on the board
SLOTA_IO7: J3A.10; also elsewhere on the board
SLOTA_IO8: J3A.13; also elsewhere on the board
SLOTA_IO9: J3A.14; also elsewhere on the board
SLOTA_IO10: J3A.15; also elsewhere on the board
SLOTA_IO11: J3A.16; also elsewhere on the board
SLOTB_IO0: J3A.17; also elsewhere on the board
SLOTB_IO1: J3A.18; also elsewhere on the board
SLOTB_IO2: J3A.19; also elsewhere on the board
SLOTB_IO3: J3A.20; also elsewhere on the board
SLOTB_IO4: J3A.23; also elsewhere on the board
SLOTB_IO5: J3A.24; also elsewhere on the board
SLOTB_IO6: J3A.25; also elsewhere on the board
SLOTB_IO7: J3A.26; also elsewhere on the board
SLOTB_IO8: J3A.29; also elsewhere on the board
SLOTB_IO9: J3A.30; also elsewhere on the board
SLOTB_IO10: J3A.31; also elsewhere on the board
SLOTB_IO11: J3A.32; also elsewhere on the board
SLOTC_IO0: J3B.1; also elsewhere on the board
SLOTC_IO1: J3B.2; also elsewhere on the board
SLOTC_IO2: J3B.3; also elsewhere on the board
SLOTC_IO3: J3B.4; also elsewhere on the board
SLOTC_IO4: J3B.7; also elsewhere on the board
SLOTC_IO5: J3B.8; also elsewhere on the board
SLOTC_IO6: J3B.9; also elsewhere on the board
SLOTC_IO7: J3B.10; also elsewhere on the board
SLOTC_IO8: J3B.13; also elsewhere on the board
SLOTC_IO9: J3B.14; also elsewhere on the board
SLOTC_IO10: J3B.15; also elsewhere on the board
SLOTC_IO11: J3B.16; also elsewhere on the board
SLOTD_IO0: J3B.17; also elsewhere on the board
SLOTD_IO1: J3B.18; also elsewhere on the board
SLOTD_IO2: J3B.19; also elsewhere on the board
SLOTD_IO3: J3B.20; also elsewhere on the board
SLOTD_IO4: J3B.23; also elsewhere on the board
SLOTD_IO5: J3B.24; also elsewhere on the board
SLOTD_IO6: J3B.25; also elsewhere on the board
SLOTD_IO7: J3B.26; also elsewhere on the board
SLOTD_IO8: J3B.29; also elsewhere on the board
SLOTD_IO9: J3B.30; also elsewhere on the board
SLOTD_IO10: J3B.31; also elsewhere on the board
SLOTD_IO11: J3B.32; also elsewhere on the board
SLOTE_IO0: J5A.32; also elsewhere on the board
SLOTE_IO1: J5A.31; also elsewhere on the board
SLOTE_IO2: J5A.30; also elsewhere on the board
SLOTE_IO3: J5A.29; also elsewhere on the board
SLOTE_IO4: J5A.26; also elsewhere on the board
SLOTE_IO5: J5A.25; also elsewhere on the board
SLOTE_IO6: J5A.24; also elsewhere on the board
SLOTE_IO7: J5A.23; also elsewhere on the board
SLOTE_IO8: J5A.20; also elsewhere on the board
SLOTE_IO9: J5A.19; also elsewhere on the board
SLOTE_IO10: J5A.18; also elsewhere on the board
SLOTE_IO11: J5A.17; also elsewhere on the board
SLOTF_IO0: J5A.16; also elsewhere on the board
SLOTF_IO1: J5A.15; also elsewhere on the board
SLOTF_IO2: J5A.14; also elsewhere on the board
SLOTF_IO3: J5A.13; also elsewhere on the board
SLOTF_IO4: J5A.10; also elsewhere on the board
SLOTF_IO5: J5A.9; also elsewhere on the board
SLOTF_IO6: J5A.8; also elsewhere on the board
SLOTF_IO7: J5A.7; also elsewhere on the board
SLOTF_IO8: J5A.4; also elsewhere on the board
SLOTF_IO9: J5A.3; also elsewhere on the board
SLOTF_IO10: J5A.2; also elsewhere on the board
SLOTF_IO11: J5A.1; also elsewhere on the board
SLOTG_IO0: J5B.32; also elsewhere on the board
SLOTG_IO1: J5B.31; also elsewhere on the board
SLOTG_IO2: J5B.30; also elsewhere on the board
SLOTG_IO3: J5B.29; also elsewhere on the board
SLOTG_IO4: J5B.26; also elsewhere on the board
SLOTG_IO5: J5B.25; also elsewhere on the board
SLOTG_IO6: J5B.24; also elsewhere on the board
SLOTG_IO7: J5B.23; also elsewhere on the board
SLOTG_IO8: J5B.20; also elsewhere on the board
SLOTG_IO9: J5B.19; also elsewhere on the board
SLOTG_IO10: J5B.18; also elsewhere on the board
SLOTG_IO11: J5B.17; also elsewhere on the board
SLOTH_IO0: J5B.16; also elsewhere on the board
SLOTH_IO1: J5B.15; also elsewhere on the board
SLOTH_IO2: J5B.14; also elsewhere on the board
SLOTH_IO3: J5B.13; also elsewhere on the board
SLOTH_IO4: J5B.10; also elsewhere on the board
SLOTH_IO5: J5B.9; also elsewhere on the board
SLOTH_IO6: J5B.8; also elsewhere on the board
SLOTH_IO7: J5B.7; also elsewhere on the board
SLOTH_IO8: J5B.4; also elsewhere on the board
SLOTH_IO9: J5B.3; also elsewhere on the board
SLOTH_IO10: J5B.2; also elsewhere on the board
SLOTH_IO11: J5B.1; also elsewhere on the board
SLOT_A_3V3: C148.1, F11.2, J53.3
SLOT_A_5V: F10.2, J53.5
SLOT_A_AUX: F12.2, J53.7
SLOT_A_PIN_VOLTAGE: C147.1, F9.2, J53.1
SLOT_B_3V3: C150.1, F15.2, J62.3
SLOT_B_5V: F14.2, J62.5
SLOT_B_AUX: F16.2, J62.7
SLOT_B_PIN_VOLTAGE: C149.1, F13.2, J62.1
SLOT_C_3V3: C152.1, F19.2, J54.3
SLOT_C_5V: F18.2, J54.5
SLOT_C_AUX: F20.2, J54.7
SLOT_C_PIN_VOLTAGE: C151.1, F17.2, J54.1
SLOT_D_3V3: C154.1, F23.2, J63.3
SLOT_D_5V: F22.2, J63.5
SLOT_D_AUX: F24.2, J63.7
SLOT_D_PIN_VOLTAGE: C153.1, F21.2, J63.1
SLOT_E_3V3: C156.1, F27.2, J55.3
SLOT_E_5V: F26.2, J55.5
SLOT_E_AUX: F28.2, J55.7
SLOT_E_PIN_VOLTAGE: C155.1, F25.2, J55.1
SLOT_F_3V3: C158.1, F31.2, J64.3
SLOT_F_5V: F30.2, J64.5
SLOT_F_AUX: F32.2, J64.7
SLOT_F_PIN_VOLTAGE: C157.1, F29.2, J64.1
SLOT_G_3V3: C160.1, F35.2, J56.3
SLOT_G_5V: F34.2, J56.5
SLOT_G_AUX: F36.2, J56.7
SLOT_G_PIN_VOLTAGE: C159.1, F33.2, J56.1
SLOT_H_3V3: C162.1, F39.2, J65.3
SLOT_H_5V: F38.2, J65.5
SLOT_H_AUX: F40.2, J65.7
SLOT_H_PIN_VOLTAGE: C161.1, F37.2, J65.1
SLOT_L_3V3: C144.1, F3.2, J57.3
SLOT_L_5V: F2.2, J57.5
SLOT_L_AUX: F4.2, J57.7
SLOT_L_PIN_VOLTAGE: C143.1, F1.2, J57.1
SLOT_M_3V3: C146.1, F7.2, J58.3
SLOT_M_5V: F6.2, J58.5
SLOT_M_AUX: F8.2, J58.7
SLOT_M_PIN_VOLTAGE: C145.1, F5.2, J58.1
VCCIO_1: C163.1, C164.1, J19.2, J19.4, J19.6; also elsewhere on the board
VCCIO_1_EXT: F9.1, F13.1, F17.1, F21.1; also elsewhere on the board
VCCIO_2: C165.1, C166.1, J20.2, J20.4, J20.6; also elsewhere on the board
VCCIO_2_EXT: F25.1, F29.1, F33.1, F37.1; also elsewhere on the board

Notes on the sheet:
SLOTS — Ten keyed extension ports, branch fusing and level shifting — HW 0.1.0-proto.1
5V BUS 0 converter
Lets the FPGA (3.3 V) talk to 5 V extensions on slot L. U9 shifts eight lines between 3.3 V and 5 V, all in one direction at a time (BUS5V0_DIR). It stays off until the FPGA pulls BUS5V0_OE_N low; the pull-up keeps the bus off while the FPGA is still loading.
5V BUS 1 converter
Same as 5V BUS 0, for slot M: U10 shifts eight lines between the FPGA's 3.3 V and 5 V, direction BUS5V1_DIR, off until BUS5V1_OE_N goes low.
SHIELD HEADER AB
First half of the right-edge 2x32 signal lattice: a 2x16 socket carrying the signals of slots A and B, twelve FPGA pins each (bank 15), with grounds between groups. Their voltage is whatever J19 selects. J3B continues the same 2.54 mm lattice end to end.
SHIELD HEADER CD
Second half of the right-edge lattice, end to end with J3A: the signals of slots C and D (bank 15, voltage set by J19).
SHIELD HEADER EF
First half of the left-edge 2x32 signal lattice: a 2x16 socket carrying the signals of slots E and F, twelve FPGA pins each (bank 34), voltage set by J20. J5B continues the lattice end to end.
SHIELD HEADER GH
Second half of the left-edge lattice, end to end with J5A: the signals of slots G and H (bank 34, voltage set by J20).
SHIELD HEADER L
The signal socket of slot L (5V BUS 0): eight 5 V data lines from U9, with four grounds between them.
SHIELD HEADER M
The signal socket of slot M (5V BUS 1): eight 5 V data lines from U10, with four grounds between them.
SLOT L branches
Power for whatever is plugged into slot L. The 1x7 power socket carries PIN V (3.3 V), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin in front 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
SLOT M branches
Power for whatever is plugged into slot M. The 1x7 power socket carries PIN V (3.3 V), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin in front 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
SLOT A branches
Power for whatever is plugged into slot A. The 1x7 power socket carries PIN V (the J19 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT B branches
Power for whatever is plugged into slot B. The 1x7 power socket carries PIN V (the J19 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT C branches
Power for whatever is plugged into slot C. The 1x7 power socket carries PIN V (the J19 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT D branches
Power for whatever is plugged into slot D. The 1x7 power socket carries PIN V (the J19 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT E branches
Power for whatever is plugged into slot E. The 1x7 power socket carries PIN V (the J20 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT F branches
Power for whatever is plugged into slot F. The 1x7 power socket carries PIN V (the J20 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT G branches
Power for whatever is plugged into slot G. The 1x7 power socket carries PIN V (the J20 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
SLOT H branches
Power for whatever is plugged into slot H. The 1x7 power socket carries PIN V (the J20 voltage), 3.3 V, 5 V and AUX, each beside a ground, and each through its own resettable fuse, so a short on one extension trips only that slot's fuse and the rest of the board keeps running. The long grounded pin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
VCCIO_1 selector
Jumper that picks the signal voltage of slots A-D: one shunt on J19 selects 3.3, 2.5 or 1.8 V. It powers FPGA bank 15 and the PIN V pin of those four slots. One position only; change it with the board unpowered.
VCCIO_2 selector
