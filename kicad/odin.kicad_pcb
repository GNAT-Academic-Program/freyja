# Repository GNAT-Academic-Program/freyja (continued)

## KiCad design kicad/odin.kicad_pcb (continued)

Schematic: power.kicad_sch

Parts:
C184: 10nF 25V; C_0402_1005Metric
C185, C186, C192, C267: 10uF 50V; C_1210_3225Metric; LCSC C77102
C187: 10uF 25V; C_0805_2012Metric; LCSC C15850
C188, C193, C200, C203, C225, C226, C227, C228, C229, C230, C262, C263, C271, C274, C277, C278, C285, C286: 100nF; C_0402_1005Metric; LCSC C1525
C189, C190, C191, C195, C196, C197, C198, C199, C201, C202, C207, C211, C212, C265, C266: 22uF; C_0805_2012Metric; LCSC C86816
C218, C219, C220, C221, C273, C276, C280, C281, C283: 1uF; C_0603_1608Metric; LCSC C29936
C261, C279: 10uF; C_0805_2012Metric; LCSC C15850
C264: 100nF 25V; C_0402_1005Metric; LCSC C1525
C268, C269: 4.7uF; C_0603_1608Metric; LCSC C277476
C272, C275: 1nF 50V; C_0402_1005Metric
C282, C284: 220nF 50V; C_0603_1608Metric
D3, D4: SS54; SMA_L4.3-W2.6-LS5.2-RD; LCSC C22452
D8: SMBJ22A; D_SMB; LCSC C151920
D24: 1N4148W; D_SOD-123; LCSC C81598
FB1: 120R 2A BLM18PG121SN1D; L_0603_1608Metric; LCSC C14709
J50: 9-21V POWER IN; CONN-TH_P5.00_KF301-5.0-2P; LCSC C474881
J68: AUX IN 9-28V UNREGULATED; CONN-TH_P5.00_KF301-5.0-2P; LCSC C474881
L2, L3: 10uH MWSA0603S-100MT; IND-SMD_L7.0-W6.6_MWSA0603S; LCSC C132141
L4, L5: 2.2uH SRN4018-2R2M; IND-SMD_L4.0-W4.0_SNR4018; LCSC C913207
L7: 4.7uH SWPA6045S4R7MT; IND-SMD_L6.0-W6.0_SWPA6045S; LCSC C78804
Q6, Q7: BSS138LT1G; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC C82045
R50: 110k; R_0603_1608Metric
R51: 24.9k; R_0603_1608Metric
R52: 14.7k; R_0603_1608Metric
R54, R168: 29.4k; R_0603_1608Metric
R55, R57, R59: 100k 0.1%; R_0603_1608Metric; LCSC C122538
R56: 24.9k 0.1%; R_0603_1608Metric; LCSC C136967
R58: 43.2k 0.1%; R_0603_1608Metric; LCSC C861404
R60: 31.6k 0.1%; R_0603_1608Metric; LCSC C705766
R61: 102k 0.1%; R_0603_1608Metric; LCSC C861068
R62: 49.9k 0.1%; R_0603_1608Metric; LCSC C705780
R67: 3.09k 0.1%; R_0603_1608Metric; LCSC C861371
R68: 10k 0.1%; R_0603_1608Metric; LCSC C95204
R72, R81, R83, R91, R94, R162, R164, R166, R201: 100k; R_0603_1608Metric
R73, R169, R207: 10k; R_0603_1608Metric
R74: 604; R_0603_1608Metric
R75: 1.15k; R_0603_1608Metric
R82: 16k; R_0603_1608Metric
R84: 47k; R_0603_1608Metric
R85, R86, R87, R88, R198, R199: 1k; R_0603_1608Metric
R163: 36.5k; R_0603_1608Metric
R165: 23.2k; R_0603_1608Metric
R167: 56.2k; R_0603_1608Metric
R200: 470k; R_0603_1608Metric
R202: 33k; R_0603_1608Metric
U11, U12: LMR33630ADDAR; ESOP-8_L4.9-W3.9-P1.27-LS6.0-TL-EP; LCSC C841384
U13, U14: TLV62569PDRLR; SOT-563_L1.6-W1.2-P0.50-LS1.6-BL; LCSC C398364
U15: TPS564201DDCR; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; LCSC C464812
U21, U22: TPS22950CDDCR; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL_3; LCSC C7587833
U23, U24: TPS22975DSGR; WSON-8_L2.0-W2.0-P0.50-TL-EP; LCSC C524777
U26: TPS25942ARVCR; QFN-20_L4.0-W3.0-P0.5-BL-EP; LCSC C181295
U34: TPS2121RUXR; Texas_VQFN-HR-12_2x2.5mm_P0.5mm; LCSC C485916

Connections:
+1V0: C211.1, C212.1, L7.1, R67.1, R88.1; also elsewhere on the board
+1V8: FB1.2, R87.1; also elsewhere on the board
+1V8_IO: C201.1, C202.1, C261.1, C262.1, FB1.1, L5.1, R61.1; also elsewhere on the board
+2V5: C198.1, C199.1, L4.1, R59.1, R86.1; also elsewhere on the board
+3V3: C195.1, C196.1, C197.1, C219.1, C271.1, C274.1, L3.1, R57.1, R73.1, R85.1, R166.1, R169.1, U22.2 (VIN), U23.4 (VBIAS), U24.4 (VBIAS); also elsewhere on the board
+3V3_EXT: U22.5 (VOUT); also elsewhere on the board
+5V: C200.1, C203.1, C207.1, C218.1, C265.1, C266.1, C268.1, C269.1, C286.1, R83.1, U13.3 (VIN), U14.3 (VIN), U14.5 (EN), U15.3 (VIN), U21.2 (VIN), U34.1 (OUT), U34.8 (OUT); also elsewhere on the board
+5V_BUCK: C189.1, C190.1, C191.1, C280.1, L2.1, R55.1, U34.2 (IN2)
+5V_EXT: U21.5 (VOUT); also elsewhere on the board
AUX_RAIL: J68.1; also elsewhere on the board
BOOT_3V3: C193.1, U12.7 (BOOT)
BOOT_5V: C188.1, U11.7 (BOOT)
BST+1V0: C285.1, U15.6 (VBST)
EN_1V0: R94.1, U15.5 (EN); also elsewhere on the board
EN_2V5: R91.1, U13.5 (EN); also elsewhere on the board
EXT_EN: R72.1, U21.1 (ON), U22.1 (ON), U23.3 (ON), U24.3 (ON); also elsewhere on the board
EXT_FAULT: R73.2, U21.6 (FLT), U22.6 (FLT), U26.20 (FLT); also elsewhere on the board
EXT_PRESENT: Q7.1 (G), R201.2, R202.1
FB+1V0: R67.2, R68.1, U15.4 (VFB)
FB+1V8_IO: R61.2, R62.1, U14.1 (FB)
FB+2V5: R59.2, R60.1, U13.1 (FB)
FB_3V3: R57.2, R58.1, U12.5 (FB)
FB_5V: R55.2, R56.1, U11.5 (FB)
GND: C184.2, C185.2, C186.2, C187.2, C189.2, C190.2, C191.2, C192.2, C195.2, C196.2, C197.2, C198.2, C199.2, C200.2, C201.2, C202.2, C203.2, C207.2, C211.2, C212.2, C218.2, C219.2, C220.2, C221.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C261.2, C262.2, C263.2, C264.2, C265.2, C266.2, C267.2, C268.2, C269.2, C271.2, C272.2, C273.2, C274.2, C275.2, C276.2, C277.2, C278.2, C279.2, C280.2, C281.2, C282.2, C283.2, C284.2, C286.2, D8.2 (A), J50.2, J68.2, Q6.2 (S), Q7.2 (S), R52.2, R54.2, R56.2, R58.2, R60.2, R62.2, R68.2, R72.2, R74.2, R75.2, R82.2, R84.2, R91.2, R94.2, R163.2, R165.2, R167.2, R168.2, R200.2, R202.2, R207.2, U11.1 (GND), U11.9 (GND), U12.1 (GND), U12.9 (GND), U13.2 (GND), U14.2 (GND), U15.1 (GND), U21.3 (GND), U22.3 (GND), U23.5 (GND), U23.9 (EP), U24.5 (GND), U24.9 (EP), U26.1 (DMODE), U26.3 (PGTH), U26.16 (GND), U26.21 (EP), U34.4 (OV2), U34.12 (GND); also elsewhere on the board
MON_1V0: C230.1, R88.2; also elsewhere on the board
MON_1V8: C229.1, R87.2; also elsewhere on the board
MON_2V5: C228.1, R86.2; also elsewhere on the board
MON_3V3: C227.1, R85.2; also elsewhere on the board
MON_5V: C226.1, R83.2, R84.1; also elsewhere on the board
MON_VCCIO_1: C277.1, R198.2; also elsewhere on the board
MON_VCCIO_2: C278.1, R199.2; also elsewhere on the board
MON_VSYS: C225.1, R81.2, R82.1; also elsewhere on the board
PD_REQ_9V: D24.2 (A); also elsewhere on the board
SEL_IN2: C279.1, D24.1 (K), Q6.1 (G), R200.1
SW+1V0: C285.2, L7.2, U15.2 (SW)
SW+1V8_IO: L5.2, U14.4 (SW)
SW+2V5: L4.2, U13.4 (SW)
SW_3V3: C193.2, L3.2, U12.8 (SW)
SW_5V: C188.2, L2.2, U11.8 (SW)
U11_VCC: C281.1, U11.6 (VCC)
U12_VCC: C283.1, U12.6 (VCC)
U21_ILIM: R74.1, U21.4 (ILIM)
U22_ILIM: R75.1, U22.4 (ILIM)
U23_CT: C272.1, U23.6 (CT)
U24_CT: C275.1, U24.6 (CT)
VBUS: C187.1, C264.1, R50.1, R162.1, R164.1, U26.9 (IN), U26.10 (IN), U26.11 (IN), U26.12 (IN), U26.13 (IN), U34.7 (IN1); also elsewhere on the board
VBUS5_CP2: R166.2, R167.1, U34.3 (CP2)
VBUS5_ILIM: R168.1, U34.10 (ILIM)
VBUS5_OV1: R164.2, R165.1, U34.5 (OV1)
VBUS5_PR1: Q6.3 (D), Q7.3 (D), R162.2, R163.1, U34.6 (PR1)
VBUS5_SS: C263.1, U34.11 (SS)
VBUS5_ST: R169.2, U34.9 (ST); also elsewhere on the board
VBUS_DVDT: C184.1, U26.18 (dVdT)
VBUS_ILM: R54.1, U26.17 (ILIM)
VBUS_IMON: R207.1, U26.19 (IMON)
VBUS_OVLO: R51.2, R52.1, U26.15 (OVP)
VBUS_SS: D3.2 (A), U26.4 (OUT), U26.5 (OUT), U26.6 (OUT), U26.7 (OUT), U26.8 (OUT)
VBUS_UVLO: R50.2, R51.1, U26.14 (EN/UVLO)
VCCIO_1: C220.1, R198.1, U23.1 (VIN), U23.2 (VIN); also elsewhere on the board
VCCIO_1_EXT: C273.1, U23.7 (VOUT), U23.8 (VOUT); also elsewhere on the board
VCCIO_2: C221.1, R199.1, U24.1 (VIN), U24.2 (VIN); also elsewhere on the board
VCCIO_2_EXT: C276.1, U24.7 (VOUT), U24.8 (VOUT); also elsewhere on the board
VIN_EXT: D4.2 (A), D8.1 (K), J50.1, R201.1
VSYS: C185.1, C186.1, C192.1, C267.1, C282.1, C284.1, D3.1 (K), D4.1 (K), R81.1, U11.2 (VIN), U11.3 (EN), U12.2 (VIN), U12.3 (EN)

Notes on the sheet:
POWER — Power tree: VSYS input, regulators, AUX IN pass-through and monitoring — HW 0.1.0-proto.1
input OR-ing
Where power enters. Two inputs feed one internal supply, VSYS: USB-C (5 V, or 9 V when a USB-PD charger agrees) and the J50 screw terminal (9-21 V). A diode on each (D3, D4) lets whichever is higher supply the board and stops one input from back-feeding the other. On the USB side, U26 is an electro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
U11 VSYS to +5V
Switching regulator (buck converter) that makes +5V from VSYS. It runs whenever power is present (no enable), like U12, so the FPGA's 1.8 V auxiliary supply is never missing while its 3.3 V banks are powered. Its output goes to the +5V rail through U34. +5V feeds the 5 V buses, the extension 5 V pi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
U12 VSYS to +3V3 (always on)
Switching regulator that makes +3V3 from VSYS. It has no enable: it starts as soon as any power is present, because +3V3 runs the board controller, which then switches everything else on. Also powers the PSRAM, the flashes, the PHY and most logic. The two feedback resistors set 3.3 V; the inductor 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
U13 5V to +2V5
Small switching regulator that makes +2V5 from +5V for FPGA bank 16 (network) and the PHY's RGMII pins. Enabled by the board controller (EN_2V5); the feedback resistors set 2.5 V.
U14 5V to +1V8_IO
Small switching regulator that makes 1.8 V from +5V. Its output node is +1V8_IO: FPGA bank 13 and the 1.8 V memory on it, the 1.8 V position of the J19/J20 jumpers, and, through the bead below, the FPGA's auxiliary supply (VCCAUX) and its ADC as +1V8. Its enable is tied to +5V, so it runs whenever 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
U15 5V to +1V0 (4A FPGA core supply)
The FPGA core supply: up to 4 A at 1.0 V from +5V, the heaviest rail on the board. Enabled by the board controller (EN_1V0) once +5V is settled above its 4.5 V minimum; firmware watches the rail through MON_1V0 (the part has no power-good pin). The feedback resistors set 1.0 V; the bootstrap capaci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
extension power protection control
Shared control for the four protected extension supplies (U21-U24). EXT_EN, from the board controller, turns them all on; the pull-down keeps them off until firmware decides. EXT_FAULT is pulled up and goes low if any of them (or the USB eFuse) detects a fault, so one controller pin hears all of th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
U21 +5V to +5V_EXT
Protected switch between the board's +5V and the 5 V pins of every extension port. Limits current to about 1 A and blocks current flowing back from an extension. Without it, a shorted extension would pull the whole board's 5 V down.
U22 +3V3 to +3V3_EXT
Protected switch between +3V3 and the 3.3 V pins of every extension port, limited to about 0.5 A, with reverse blocking. Keeps a faulty extension from taking down the board controller's supply.
U23 VCCIO_1 to VCCIO_1_EXT
Switch for the PIN V supply of slots A-D (the voltage chosen on J19). It is biased from +3V3 so it works down to the 1.8 V setting, blocks current flowing back in while off, ramps its output in about 1.5 ms and shuts down when hot. Overload protection is each slot's 500 mA fuse; the switch itself h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
U24 VCCIO_2 to VCCIO_2_EXT
Switch for the PIN V supply of slots E-H (the voltage chosen on J20). It is biased from +3V3 so it works down to the 1.8 V setting, blocks current flowing back in while off, ramps its output in about 1.5 ms and shuts down when hot. Overload protection is each slot's 500 mA fuse; the switch itself h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
rail monitors
Lets the board controller measure every supply. Each rail goes to one of its eight analog inputs (ADC), which read 0-3.3 V. Rails at or below 3.3 V go through a 1 k resistor that protects the pin; VSYS and +5V are higher, so two resistors divide them down first. A 100 nF capacitor on each input ste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
AUX IN
Optional extra power for extensions that need more than 5 V (motors, LED strips, displays). Whatever you connect here (9-28 V DC) goes, unregulated, to the AUX pin of every extension port through each port's own fuse. The board itself never uses it.
VCCAUX filter
The split between +1V8_IO and +1V8. VCCAUX and VCCADC are the FPGA's internal supplies (clocking, I/O pre- drivers, the XADC) and should not share copper with switching 1.8 V I/O loads, so they hang off U14's output through one ferrite bead (120 ohm at 100 MHz, 2 A, 50 mohm: 9 mV at the 0.18 A VCCA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
U34 +5V source select
Chooses what feeds the +5V rail: USB power straight from the connector, or U11. A regulator cannot make 5 V out of 5 V, so on a plain 5 V USB source the mux passes VBUS to the rail. It hands the rail to U11 while the board controller asks the charger for 9 V and for a few seconds after (Q6), while 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
Q6 mux hold: 9 V request
Keeps U34 on U11 around a 9 V negotiation. The controller's 9 V request charges a capacitor through D24 at once and the capacitor drains through its resistor in 2-7 s, so the rail leaves VBUS before the charger moves it and returns only when VBUS is back at 5 V. No voltage threshold can do that wit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
Q7 mux hold: screw input present
Keeps U34 on U11 whenever the screw input carries voltage, so a bench supply on J50 carries the whole board even with a 5 V USB cable plugged in; before, the USB port kept the 5 V load.
Power flags for the rails made on this page

Schematic: memory.kicad_sch

Parts:
C111, C112, C113, C114, C115, C250, C251, C252, C253, C254, C255, C256, C258, C259: 100nF; C_0402_1005Metric; LCSC C1525
C257, C260: 10uF; C_0805_2012Metric; LCSC C15850
J74: microSD; TF-SMD_TF-01A-NPTH; LCSC C91145
R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121, R122, R123, R124, R125, R126, R127: 33; R_0402_1005Metric; LCSC C25105
R151: 22; R_0402_1005Metric
R152, R153, R154, R155, R156, R157, R158, R159, R160, R161, R174, R175, R176, R177, R178, R179, R180, R181, R182, R183, R184, R185, R186, R187, R188, R189, R190, R191, R192, R193, R194, R195, R196, R197: 10k; R_0603_1608Metric
U2, U3, U4, U5: APS6404L-SQN-SN; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; LCSC C5360304
U6: W25Q256JVEIQ; WSON-8_L8.0-W6.10-P1.27-BL-EP; LCSC C97522
U32: W9825G6KH-6; TSOP-II-54_22.2x10.16mm_P0.8mm; LCSC C62246
U33: MR25H10CDF; DFN-8_L5.0-W6.0-P1.27-EP2.0-2VIA; LCSC C246234

Connections:
+1V8_IO: C111.1, C112.1, C113.1, C114.1, R174.1, R180.1, R186.1, R192.1, U2.8 (VDD), U3.8 (VDD), U4.8 (VDD), U5.8 (VDD); also elsewhere on the board
+3V3: C115.1, C250.1, C251.1, C252.1, C253.1, C254.1, C255.1, C256.1, C257.1, C258.1, C259.1, C260.1, J74.4 (VDD), R152.1, R154.1, R155.1, R156.1, R157.1, R158.1, R159.1, R160.1, R161.1, U6.8 (VCC), U32.1 (VDD), U32.3 (VDDQ), U32.9 (VDDQ), U32.14 (VDD), U32.27 (VDD), U32.43 (VDDQ), U32.49 (VDDQ), U33.8 (VDD); also elsewhere on the board
CFG_CCLK: U6.6 (CLK); also elsewhere on the board
FLASH_CS_B: U6.1 (~CS); also elsewhere on the board
FLASH_D0_MOSI: U6.5 (DI/IO0); also elsewhere on the board
FLASH_D1_MISO: U6.2 (DO/IO1); also elsewhere on the board
FLASH_D2_WP: U6.3 (~WP/IO2); also elsewhere on the board
FLASH_D3_HOLD: U6.7 (~HOLD/IO3); also elsewhere on the board
GND: C111.2, C112.2, C113.2, C114.2, C115.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, C259.2, C260.2, J74.6 (VSS), J74.10 (GND), J74.11 (GND), J74.12 (GND), J74.13 (GND), R153.2, R175.2, R176.2, R177.2, R178.2, R179.2, R181.2, R182.2, R183.2, R184.2, R185.2, R187.2, R188.2, R189.2, R190.2, R191.2, R193.2, R194.2, R195.2, R196.2, R197.2, U2.4 (VSS), U3.4 (VSS), U4.4 (VSS), U5.4 (VSS), U6.4 (GND), U6.9 (EP), U32.6 (VSSQ), U32.12 (VSSQ), U32.28 (VSS), U32.41 (VSS), U32.46 (VSSQ), U32.52 (VSSQ), U32.54 (VSS), U33.4 (VSS), U33.9 (EP); also elsewhere on the board
MRAM_CS: R154.2, U33.1 (~CS); also elsewhere on the board
MRAM_HOLD: R156.2, U33.7 (~HOLD)
MRAM_SCK: U33.6 (SCK); also elsewhere on the board
MRAM_SI: U33.5 (SI); also elsewhere on the board
MRAM_SO: U33.2 (SO); also elsewhere on the board
MRAM_WP: R155.2, U33.3 (~WP)
PSRAM0_CE_B: R105.1; also elsewhere on the board
PSRAM0_CE_B_MEM: R105.2, R174.2, U2.1 (~CE)
PSRAM0_IO0: R106.1; also elsewhere on the board
PSRAM0_IO0_MEM: R106.2, R176.1, U2.5 (SI/SIO0)
PSRAM0_IO1: R107.1; also elsewhere on the board
PSRAM0_IO1_MEM: R107.2, R177.1, U2.2 (SO/SIO1)
PSRAM0_IO2: R108.1; also elsewhere on the board
PSRAM0_IO2_MEM: R108.2, R178.1, U2.3 (SIO2)
PSRAM0_IO3: R109.1; also elsewhere on the board
PSRAM0_IO3_MEM: R109.2, R179.1, U2.7 (SIO3)
PSRAM0_SCK: R104.1; also elsewhere on the board
PSRAM0_SCK_MEM: R104.2, R175.1, U2.6 (SCLK)
PSRAM1_CE_B: R111.1; also elsewhere on the board
PSRAM1_CE_B_MEM: R111.2, R180.2, U3.1 (~CE)
PSRAM1_IO0: R112.1; also elsewhere on the board
PSRAM1_IO0_MEM: R112.2, R182.1, U3.5 (SI/SIO0)
PSRAM1_IO1: R113.1; also elsewhere on the board
PSRAM1_IO1_MEM: R113.2, R183.1, U3.2 (SO/SIO1)
PSRAM1_IO2: R114.1; also elsewhere on the board
PSRAM1_IO2_MEM: R114.2, R184.1, U3.3 (SIO2)
PSRAM1_IO3: R115.1; also elsewhere on the board
PSRAM1_IO3_MEM: R115.2, R185.1, U3.7 (SIO3)
PSRAM1_SCK: R110.1; also elsewhere on the board
PSRAM1_SCK_MEM: R110.2, R181.1, U3.6 (SCLK)
PSRAM2_CE_B: R117.1; also elsewhere on the board
PSRAM2_CE_B_MEM: R117.2, R186.2, U4.1 (~CE)
PSRAM2_IO0: R118.1; also elsewhere on the board
PSRAM2_IO0_MEM: R118.2, R188.1, U4.5 (SI/SIO0)
PSRAM2_IO1: R119.1; also elsewhere on the board
PSRAM2_IO1_MEM: R119.2, R189.1, U4.2 (SO/SIO1)
PSRAM2_IO2: R120.1; also elsewhere on the board
PSRAM2_IO2_MEM: R120.2, R190.1, U4.3 (SIO2)
PSRAM2_IO3: R121.1; also elsewhere on the board
PSRAM2_IO3_MEM: R121.2, R191.1, U4.7 (SIO3)
PSRAM2_SCK: R116.1; also elsewhere on the board
PSRAM2_SCK_MEM: R116.2, R187.1, U4.6 (SCLK)
PSRAM3_CE_B: R123.1; also elsewhere on the board
PSRAM3_CE_B_MEM: R123.2, R192.2, U5.1 (~CE)
PSRAM3_IO0: R124.1; also elsewhere on the board
PSRAM3_IO0_MEM: R124.2, R194.1, U5.5 (SI/SIO0)
PSRAM3_IO1: R125.1; also elsewhere on the board
PSRAM3_IO1_MEM: R125.2, R195.1, U5.2 (SO/SIO1)
PSRAM3_IO2: R126.1; also elsewhere on the board
PSRAM3_IO2_MEM: R126.2, R196.1, U5.3 (SIO2)
PSRAM3_IO3: R127.1; also elsewhere on the board
PSRAM3_IO3_MEM: R127.2, R197.1, U5.7 (SIO3)
PSRAM3_SCK: R122.1; also elsewhere on the board
PSRAM3_SCK_MEM: R122.2, R193.1, U5.6 (SCLK)
SDRAM_A0: U32.23 (A0); also elsewhere on the board
SDRAM_A1: U32.24 (A1); also elsewhere on the board
SDRAM_A2: U32.25 (A2); also elsewhere on the board
SDRAM_A3: U32.26 (A3); also elsewhere on the board
SDRAM_A4: U32.29 (A4); also elsewhere on the board
SDRAM_A5: U32.30 (A5); also elsewhere on the board
SDRAM_A6: U32.31 (A6); also elsewhere on the board
SDRAM_A7: U32.32 (A7); also elsewhere on the board
SDRAM_A8: U32.33 (A8); also elsewhere on the board
SDRAM_A9: U32.34 (A9); also elsewhere on the board
SDRAM_A10: U32.22 (A10); also elsewhere on the board
SDRAM_A11: U32.35 (A11); also elsewhere on the board
SDRAM_A12: U32.36 (A12); also elsewhere on the board
SDRAM_BA0: U32.20 (BS0); also elsewhere on the board
SDRAM_BA1: U32.21 (BS1); also elsewhere on the board
SDRAM_CAS_N: U32.17 (~CAS); also elsewhere on the board
SDRAM_CKE: R153.1, U32.37 (CKE); also elsewhere on the board
SDRAM_CLK: R151.1; also elsewhere on the board
SDRAM_CLK_MEM: R151.2, U32.38 (CLK)
SDRAM_CS_N: R152.2, U32.19 (~CS); also elsewhere on the board
SDRAM_DQ0: U32.2 (DQ0); also elsewhere on the board
SDRAM_DQ1: U32.4 (DQ1); also elsewhere on the board
SDRAM_DQ2: U32.5 (DQ2); also elsewhere on the board
SDRAM_DQ3: U32.7 (DQ3); also elsewhere on the board
SDRAM_DQ4: U32.8 (DQ4); also elsewhere on the board
SDRAM_DQ5: U32.10 (DQ5); also elsewhere on the board
SDRAM_DQ6: U32.11 (DQ6); also elsewhere on the board
SDRAM_DQ7: U32.13 (DQ7); also elsewhere on the board
SDRAM_DQ8: U32.42 (DQ8); also elsewhere on the board
SDRAM_DQ9: U32.44 (DQ9); also elsewhere on the board
SDRAM_DQ10: U32.45 (DQ10); also elsewhere on the board
SDRAM_DQ11: U32.47 (DQ11); also elsewhere on the board
SDRAM_DQ12: U32.48 (DQ12); also elsewhere on the board
SDRAM_DQ13: U32.50 (DQ13); also elsewhere on the board
SDRAM_DQ14: U32.51 (DQ14); also elsewhere on the board
SDRAM_DQ15: U32.53 (DQ15); also elsewhere on the board
SDRAM_LDQM: U32.15 (LDQM); also elsewhere on the board
SDRAM_RAS_N: U32.18 (~RAS); also elsewhere on the board
SDRAM_UDQM: U32.39 (UDQM); also elsewhere on the board
SDRAM_WE_N: U32.16 (~WE); also elsewhere on the board
SD_CD: J74.9 (CD); also elsewhere on the board
SD_CS: J74.2 (CDDAT3(CS)), R157.2; also elsewhere on the board
SD_DAT1: J74.8 (DAT1(RSV)), R160.2
SD_DAT2: J74.1 (DAT2(RSV)), R161.2
SD_MISO: J74.7 (DAT0(D0)), R159.2; also elsewhere on the board
SD_MOSI: J74.3 (CMD(DI)), R158.2; also elsewhere on the board
SD_SCK: J74.5 (CLK(SCLK)); also elsewhere on the board

Notes on the sheet:
MEMORY — PSRAM x4 (independent buses, 1.8 V), SDRAM, MRAM, microSD and configuration flash — HW 0.1.0-proto.1
PSRAM0
Working-memory chip 0: 8 MB of fast RAM for the FPGA design, on its own four-bit (QSPI) bus to bank 13 at 1.8 V. The four chips are independent, so a design can use them in parallel. Notes: ref/psram.md.
PSRAM1
Working-memory chip 1: 8 MB of RAM on its own QSPI bus to bank 13, at 1.8 V.
PSRAM2
Working-memory chip 2: 8 MB of RAM on its own QSPI bus to bank 13, at 1.8 V.
PSRAM3
Working-memory chip 3: 8 MB of RAM on its own QSPI bus to bank 13, at 1.8 V.
config flash
The FPGA's non-volatile memory. At power-on the FPGA reads its design (bitstream) from this 32 MB flash by itself (master SPI, set by the mode straps). The board controller can rewrite it through the series resistors on the Board Controller sheet, and spare space can hold user data or software for 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
U1 PSRAM0 series termination
One 33 ohm resistor per PSRAM0 line, placed next to the FPGA: they soften the fast signal edges so they do not ring along the trace. Values can be tuned after measurement (ref/psram.md).
U1 PSRAM1 series termination
One 33 ohm resistor per PSRAM1 line, next to the FPGA, to damp ringing.
U1 PSRAM2 series termination
One 33 ohm resistor per PSRAM2 line, next to the FPGA, to damp ringing.
U1 PSRAM3 series termination
One 33 ohm resistor per PSRAM3 line, next to the FPGA, to damp ringing.
SDRAM
A 32 MB SDR SDRAM (Winbond W9825G6KH-6, 16 bits wide, up to 166 MHz) for designs that outgrow the PSRAMs: a framebuffer, a soft CPU's main memory, a capture buffer. Its data and control lines come from bank 35 and its address lines from bank 14, both at 3.3 V. One 100 nF per VDD/VDDQ pin pair (seve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
U1 SDRAM clock source
The 22 ohm resistor in the SDRAM clock line. It sits at the FPGA ball that drives the clock, so it damps the edge at its source; it is in U1's island, not the SDRAM's (findings 44).
MRAM
A 128 KB non-volatile SPI memory (Everspin MR25H10CDF) that keeps its contents without power and has no write wear: settings, logs, a boot menu, a save file. CS is pulled up so the chip stays deselected while power comes up (datasheet section 4); WP and HOLD are pulled up and not connected to the F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
microSD socket
A push-push microSD socket (Hroparts TF-01A) wired for SPI mode: chip select on DAT3, data in on CMD, data out on DAT0, clock on CLK, five bank 14 lines at 3.3 V including the card-detect switch. The 10k pull-ups hold CS, the two data lines and the two unused DAT lines high, as the SD specification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
PSRAM0 power-up state
Six 10k resistors at the PSRAM0 pins: CE# pulled up to its own supply, clock and the four data lines pulled down. The chip requires these levels from the first moment of its supply ramp until 150 us after it, and an unconfigured FPGA leaves its pins floating, so resistors, not the FPGA, guarantee t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
PSRAM1 power-up state
Six 10k resistors at the PSRAM1 pins: CE# up, clock and data down, from power-up (APS6404L section 8).
PSRAM2 power-up state
Six 10k resistors at the PSRAM2 pins: CE# up, clock and data down, from power-up (APS6404L section 8).
PSRAM3 power-up state
Six 10k resistors at the PSRAM3 pins: CE# up, clock and data down, from power-up (APS6404L section 8).

Schematic: supervisor.kicad_sch

Parts:
C116, C117, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128, C129, C135, C136, C138: 100nF; C_0402_1005Metric; LCSC C1525
C130, C131, C132: 4.7uF; C_0603_1608Metric; LCSC C277476
C133, C134: 15pF; C_0402_1005Metric
C137: 1uF 25V; C_0603_1608Metric; LCSC C29936
D6: ESDA6V1BC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; LCSC C495220
D7: SMBJ12A; SMB_L4.3-W3.6-LS5.3-RD; LCSC C19077565
D9, D10, D11: F.0603.00025/P2-0603G1TS2-06T-002; LED0603-RD_GREEN; LCSC C7496818
J1: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J2: FPGA JTAG; IDC-TH_10P-P2.54_C5665; LCSC C5665
J51: CTRL SWD; CONN-SMD-3P-P1.00_BM03B-SRSS-TB-LF-SN; LCSC C160389
J52: PZ254V-11-02P; HDR-TH_2P-P2.54-V-M; LCSC C492401
L1: 3.3uH AOTA-B201610S3R3-101-T; IND-SMD_L2.0-W1.6_AOTA-B201610S3R3-101-T; LCSC C42411119
R8, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 33; R_0402_1005Metric; LCSC C25105
R9, R10, R12, R128, R129, R130: 1k; R_0402_1005Metric; LCSC C11702
R13: 10k; R_0402_1005Metric; not fitted
R33, R205: 0; R_0402_1005Metric
R34: 10k; R_0603_1608Metric
R170, R171: 27; R_0402_1005Metric
R172, R204: 4.7k; R_0402_1005Metric; LCSC C25900
R173: 100k; R_0402_1005Metric; LCSC C25741
R206: 4.53k; R_0402_1005Metric
SW1: CTRL BOOT; KEY-SMD_B3U-1000PM; LCSC C231329
U7: RP2350B; QFN-80_L10.0-W10.0-P0.40-TL-EP3.4; LCSC C42415655
U8: W25Q32JVZP; WSON-8_L6.0-W5.0-P1.27-BL-EP; LCSC C571260
U18: HUSB238_002DD; DFN-10_L3.0-W3.0-P0.50-BL-EP2.5; LCSC C7471904
U20: SN74CB3Q3384APWR; TSSOP-24_L7.8-W4.4-P0.65-LS6.4-BL; LCSC C469874
Y1: 12MHz ABM8-272-T3; CRYSTAL-SMD_4P-L3.2-W2.5-BL; LCSC C20625731

Connections:
+1V1: C127.1, C128.1, C129.1, C131.1, L1.2, U7.10 (DVDD), U7.32 (DVDD), U7.51 (DVDD), U7.65 (VREG_FB)
+3V3: C116.1, C117.1, C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, C130.1, C136.1, C138.1, J2.1, J52.1, R8.1, R10.1, R13.1, R128.1, R129.1, R130.1, R172.1, R204.1, U7.5 (IOVDD), U7.15 (IOVDD), U7.24 (IOVDD), U7.29 (IOVDD), U7.41 (IOVDD), U7.50 (IOVDD), U7.59 (ADC_AVDD), U7.60 (IOVDD), U7.64 (VREG_VIN), U7.68 (USB_OTP_VDD), U7.69 (QSPI_IOVDD), U7.76 (IOVDD), U8.8 (VCC), U20.13 (~2OE), U20.24 (VCC); also elsewhere on the board
BOOTSEL_SW: R12.2, SW1.1
CFG_CCLK: R21.2; also elsewhere on the board
CFG_DONE: R20.2; also elsewhere on the board
CFG_INIT_B: R19.2; also elsewhere on the board
CFG_PROG_B: R18.2; also elsewhere on the board
DBG_TCK: R27.2; also elsewhere on the board
DBG_TDI: R29.2; also elsewhere on the board
DBG_TDO: R30.2; also elsewhere on the board
DBG_TMS: R28.2; also elsewhere on the board
EN_1V0: U7.25 (GPIO24); also elsewhere on the board
EN_2V5: U7.22 (GPIO22); also elsewhere on the board
EXTERNAL_JTAG_SELECTED: J52.2, R34.1, U20.1 (~1OE)
EXT_EN: U7.6 (GPIO8); also elsewhere on the board
EXT_FAULT: U7.43 (GPIO34); also elsewhere on the board
FLASH_CS_B: R22.2; also elsewhere on the board
FLASH_D0_MOSI: R23.2; also elsewhere on the board
FLASH_D1_MISO: R24.2; also elsewhere on the board
FLASH_D2_WP: R25.2; also elsewhere on the board
FLASH_D3_HOLD: R26.2; also elsewhere on the board
GND: C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, D6.2 (COM), D6.5 (COM), D7.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J2.4, J2.6, J2.8, J2.10, J51.2, R34.2, R173.2, R205.2, R206.2, SW1.2, U7.62 (VREG_PGND), U7.81 (GND), U8.4 (GND), U8.9 (EP), U18.11 (GND), U20.12 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
JTAG_TCK: J2.5, U20.2 (1B1); also elsewhere on the board
JTAG_TDI: J2.9, U20.6 (1B3); also elsewhere on the board
JTAG_TDO: J2.7, R33.2; also elsewhere on the board
JTAG_TDO_SW: R33.1, U20.9 (1B4)
JTAG_TMS: J2.3, U20.5 (1B2); also elsewhere on the board
LED_HEARTBEAT_A: D9.2 (A), R128.2
LED_HEARTBEAT_N: D9.1 (C), U7.44 (GPIO35)
LED_USER1_A: D10.2 (A), R129.2
LED_USER1_N: D10.1 (C), U7.45 (GPIO36)
LED_USER2_A: D11.2 (A), R130.2
LED_USER2_N: D11.1 (C), U7.46 (GPIO37)
MON_1V0: U7.56 (GPIO45/ADC5); also elsewhere on the board
MON_1V8: U7.55 (GPIO44/ADC4); also elsewhere on the board
MON_2V5: U7.54 (GPIO43/ADC3); also elsewhere on the board
MON_3V3: U7.53 (GPIO42/ADC2); also elsewhere on the board
MON_5V: U7.52 (GPIO41/ADC1); also elsewhere on the board
MON_VCCIO_1: U7.57 (GPIO46/ADC6); also elsewhere on the board
MON_VCCIO_2: U7.58 (GPIO47/ADC7); also elsewhere on the board
MON_VSYS: U7.49 (GPIO40/ADC0); also elsewhere on the board
PD_ISET: R206.1, U18.9 (ISET)
PD_REQ_9V: R173.1, U7.28 (GPIO27); also elsewhere on the board
PD_SCL: R204.2, U7.39 (GPIO31), U18.7 (SCL)
PD_SDA: R172.2, U7.13 (GPIO14), U18.6 (SDA)
PD_VSET: R205.1, U18.8 (VSET)
SB_UART_RX: R31.2; also elsewhere on the board
SB_UART_TX: R32.2; also elsewhere on the board
SUPF_CLK: U7.71 (QSPI_SCLK), U8.6 (CLK)
SUPF_CS: R12.1, R13.2, U7.75 (~QSPI_SS), U8.1 (~CS)
SUPF_D0: U7.72 (QSPI_SD0), U8.5 (DI/IO_{0})
SUPF_D1: U7.74 (QSPI_SD1), U8.2 (DO/IO_{1})
SUPF_D2: U7.73 (QSPI_SD2), U8.3 (~WP/IO_{2})
SUPF_D3: U7.70 (QSPI_SD3), U8.7 (~HOLD/~RESET/IO_{3})
SUP_CCLK: R21.1, U7.8 (GPIO10)
SUP_DBG_TCK: R27.1, U7.14 (GPIO15)
SUP_DBG_TDI: R29.1, U7.17 (GPIO17)
SUP_DBG_TDO: R30.1, U7.18 (GPIO18)
SUP_DBG_TMS: R28.1, U7.16 (GPIO16)
SUP_DONE: R20.1, U7.3 (GPIO6)
SUP_FCS_B: R22.1, U7.7 (GPIO9)
SUP_FD0: R23.1, U7.9 (GPIO11)
SUP_FD1: R24.1, U7.11 (GPIO12)
SUP_FD2: R25.1, U7.12 (GPIO13)
SUP_FD3: R26.1, U7.4 (GPIO7)
SUP_INIT_B: R19.1, U7.2 (GPIO5)
SUP_JTAG_TCK: R14.1, U7.77 (GPIO0)
SUP_JTAG_TDI: R16.1, U7.79 (GPIO2)
SUP_JTAG_TDO: R17.1, U7.80 (GPIO3)
SUP_JTAG_TMS: R15.1, U7.78 (GPIO1)
SUP_LX: L1.1, U7.63 (VREG_LX)
SUP_PROG_B: R18.1, U7.1 (GPIO4)
SUP_RUN: C135.1, R10.2, U7.35 (RUN)
SUP_SWCLK: J51.1, U7.33 (SWCLK)
SUP_SWDIO: J51.3, U7.34 (SWDIO)
SUP_UART_RX: R32.1, U7.42 (GPIO33)
SUP_UART_TX: R31.1, U7.40 (GPIO32)
SUP_VREG_AVDD: C132.1, R8.2, U7.61 (VREG_AVDD)
SUP_XIN: C133.1, U7.30 (XIN), Y1.1
SUP_XOUT: R9.1, U7.31 (XOUT)
SUP_XTAL_OUT: C134.1, R9.2, Y1.3
SWJ_TCK: R14.2, U20.3 (1A1)
SWJ_TDI: R16.2, U20.7 (1A3)
SWJ_TDO: R17.2, U20.8 (1A4)
SWJ_TMS: R15.2, U20.4 (1A2)
USB_CC1: D6.4 (TVS3), J1.A5 (CC1), U18.4 (CC1)
USB_CC2: D6.6 (TVS4), J1.B5 (CC2), U18.5 (CC2)
USB_DM: D6.3 (TVS2), J1.A7 (D-), J1.B7 (D-), R171.1
USB_DM_MCU: R171.2, U7.66 (USB_DM)
USB_DP: D6.1 (TVS1), J1.A6 (D+), J1.B6 (D+), R170.1
USB_DP_MCU: R170.2, U7.67 (USB_DP)
VBUS: C137.1, D7.1 (K), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U18.1 (VIN); also elsewhere on the board
VBUS5_ST: U7.21 (GPIO21); also elsewhere on the board

Notes on the sheet:
SUPERVISOR — Board controller: RP2350B, USB-C, startup memory and FPGA control — HW 0.1.0-proto.1
U7 board controller
The board controller, a Raspberry Pi RP2350B microcontroller that is always on. It is what the USB cable talks to: it loads designs into the FPGA over JTAG or writes them to the FPGA's flash, turns the supplies on in order and watches them, asks a USB-PD charger for 9 V, enables extension power, an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
U7 core regulator (RP-008280 s2.1)
Parts for the RP2350's built-in switching regulator, which makes its 1.1 V core supply (+1V1) from +3V3. Values and the inductor are the ones Raspberry Pi specifies in their hardware design guide (RP-008280 section 2.1).
crystal (RP-008280 s4)
The board controller's 12 MHz clock: the exact crystal, load capacitors and 1 k drive-limiting resistor Raspberry Pi specifies (RP-008280 section 4).
RUN
The board controller's reset input. The pull-up keeps it running; the capacitor holds it in reset briefly at power-on until +3V3 is stable.
board controller startup memory
The board controller's own 4 MB flash, holding its firmware. Separate from the FPGA's flash.
USB-C
The main connector: power in, and the USB link to your computer for programming and talking to the board.
USB protection
Clamps for static discharge and voltage spikes on the USB connector: D6 on the data and CC lines, D7 on the power line (VBUS).
USB-PD sink
Negotiates the supply voltage with a USB-PD charger. Out of the box it asks for 5 V at 1.5 A (the VSET and ISET strap resistors), so a dead or resetting controller leaves it at 5 V. The board controller asks for 9 V over I2C (SDA/SCL with their pull-ups) while it raises PD_REQ_9V for the +5V mux, a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
BOOTSEL
Hold CTRL BOOT while plugging in USB to put the board controller in its built-in USB bootloader, for installing or recovering its firmware. The 1 k resistor lets the button win without fighting the chip. The 10 k pull-up is not fitted, as in Raspberry Pi's design.
board controller SWD
Debug connector for the board controller's own processor (SWD): for developing its firmware with a debug probe. Not for the FPGA.
series resistors to FPGA
One 33 ohm resistor on every wire between the board controller and the FPGA: JTAG, the configuration pins, the FPGA flash bus, the debug sideband and the UART. They limit current if both sides ever drive the same wire at once, and damp ringing.
JTAG owner selection
Decides who programs the FPGA over JTAG. Normally (J52 open) the board controller does, through the U20 switch. Fit a jumper on J52 and U20 disconnects the board controller completely, so an external programmer plugged into J2 has the FPGA to itself. A jumper, not software, so it works even when th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
manual JTAG header
Standard 2x5 JTAG header for an external FPGA programmer (Xilinx/AMD cable or similar). Fit J52 first.
board status LEDs
Three green LEDs on board controller GPIO35-37, lit by driving the pin low: CTRL HB blinks while the board controller firmware is alive; USER 1 and USER 2 are for software. Each has a 1 k current-limiting resistor from +3V3. Rules: ref/status-leds.md.
U7 USB series resistors
Two 27 ohm resistors in the USB data lines, right at the board controller, as Raspberry Pi's hardware design guide (section 5.1) asks. The ESD clamp D6 stays at the connector.
Power flags for the rails made on this page
